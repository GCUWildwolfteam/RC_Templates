# Keil uVision project RC_SelfMotion.uvprojx, settings and files
target RC_SelfMotion (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RC_SelfMotion +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx
  c misc: --C99
  c include: ..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include;..\User;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\FreeRTOS\include;..\Libraries\FreeRTOS\portable\RVDS\ARM_CM4F;..\BSP;..\Apps;..\Devices;..\Task;C:\Keil_v5\ARM\ARMCC\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c User_Config.h FreeRTOSConfig.h stm32f4xx_conf.h
  group Task
    ../Task/: Task_Ctrl.c Task_Init.c Task_Usart.c Task_Can.c
  group Apps
    ../Apps/: Chassis.c Gimbal.c Joint.c Curve.c pid.c check.c protocol.c delay.c Filter.c
  group Devices
    ../Devices/: LED.c Key.c DR16.c Motor.c OLED.c Servo.c Cylinder.c Gyro.c RoboModule.c Encoder.c OpticFlow.c Camera.c Ultrasonic.c Photoelectric.c
  group BSP
    ../BSP/: BSP_GPIO.c BSP_USART.c BSP_CAN.c BSP_NVIC.c BSP_DMA.c BSP_ADC.c BSP_TIM.c BSP_I2C.c
  group FreeRTOS
    ../Libraries/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Libraries/FreeRTOS/portable/MemMang/: heap_4.c
    ../Libraries/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Libraries
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f427_437xx.s
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Doc
    ../Doc/: Readme.md
